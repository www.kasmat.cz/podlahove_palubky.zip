Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: O 24x146.IFC
Time: 2023-06-21T09:59:19
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: O 24x146
In: Default Storey
PredefinedType: ELEMENT; Material: Smrk
