Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: C+O 28x170.IFC
Time: 2023-06-22T09:10:18
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: C+O 28x170
In: Default Storey
PredefinedType: ELEMENT; Material: Smrk
